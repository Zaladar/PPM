<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Grupp7Discovrty.ewp</path>
  </project>
  <batchBuild />
</workspace>
